# IAR project 1986BE9x_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..; ..\..\inc; ..\..\..\Library\Libraries\1986BE9x_StdPeriph_Driver\inc; ..\..\..\Library\Libraries\1986BE9x_StdPeriph_Driver\inc\USB_Library; ..\..\..\Library\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Library\Libraries\CMSIS\CM3\DeviceSupport\1986BE9x\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 1986BE9x_Demo.hex
  ILINK.IlinkOutputFile: 1986BE9x_Demo.out
  ILINK.IlinkIcfFile: Milandr_1986BE9x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group 1986BE9x_FWLib
    ../../../Library/Libraries/1986BE9x_StdPeriph_Driver/src/: 1986be9x_adc.c 1986be9x_bkp.c 1986be9x_can.c 1986be9x_comp.c 1986be9x_dac.c 1986be9x_dma.c 1986be9x_eeprom.c 1986be9x_ext_bus.c 1986be9x_i2c.c 1986be9x_iwdg.c 1986be9x_port.c 1986be9x_power.c 1986be9x_rst_clk.c 1986be9x_ssp.c 1986be9x_timer.c 1986be9x_uart.c 1986be9x_usb.c 1986be9x_wwdg.c
  group 1986BE9x_USBLib
    ../../../Library/Libraries/1986BE9x_StdPeriph_Driver/src/USB_Library/: 1986BE9x_usb_CDC.c 1986BE9x_usb_device.c
  group Fonts
    ../../fonts/: Font_12x16.c Font_6x8.c Font_7x10_bold.c Font_7x10_thin.c
  group Target
    ../../../Library/Libraries/CMSIS/CM3/DeviceSupport/1986BE9x/startup/iar/: startup_1986be9x.s system_1986BE9x.c
  group User
    ../../src/: 1986BE9x_it.c adc.c Demo_Init_1986BE91.c Demo_Init_1986BE9x.c gl.c joystick.c lcd_1986BE91.c lcd_1986BE9x.c leds.c Main.c Menu.c Menu_gl.c Menu_leds.c Menu_lowpower.c Menu_text.c Menu_time.c Menu_tsensor.c Menu_uart.c Menu_VCOM.c systick.c text.c
