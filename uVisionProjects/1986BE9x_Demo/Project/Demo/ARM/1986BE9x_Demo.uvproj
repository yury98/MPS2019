# Keil uVision project 1986BE9x_Demo.uvproj, settings and files
target Milandr 1986BE9x (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 1986BE9x_Demo
  c flags: Optim=4
  c misc: --diag_suppress=47
  c include: ..\..\..\Library\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Library\Libraries\CMSIS\CM3\DeviceSupport\1986BE9x\inc;..\;..\..\Inc;..\..\..\Library\Libraries\1986BE9x_StdPeriph_Driver\inc;..\..\..\Library\Libraries\1986BE9x_StdPeriph_Driver\inc\USB_Library
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group 1986BE9x_FWLib
    ../../../Library/Libraries/1986BE9x_StdPeriph_Driver/src/: 1986be9x_wwdg.c 1986be9x_adc.c 1986be9x_bkp.c 1986be9x_can.c 1986be9x_comp.c 1986be9x_dac.c 1986be9x_dma.c 1986be9x_eeprom.c 1986be9x_ext_bus.c 1986be9x_i2c.c 1986be9x_iwdg.c 1986be9x_port.c 1986be9x_power.c 1986be9x_rst_clk.c 1986be9x_ssp.c 1986be9x_timer.c 1986be9x_uart.c 1986be9x_usb.c
  group 1986BE9x_USBLib
    ../../../Library/Libraries/1986BE9x_StdPeriph_Driver/src/USB_Library/: 1986BE9x_usb_device.c 1986BE9x_usb_CDC.c
  group Fonts
    ../../fonts/: Font_12x16.c Font_6x8.c Font_7x10_bold.c Font_7x10_thin.c
  group Target
    ../../../Library/Libraries/CMSIS/CM3/DeviceSupport/1986BE9x/startup/arm/: system_1986BE9x.c startup_1986be9x.s
  group User
    ../../src/: text.c 1986BE9x_it.c adc.c Demo_Init_1986BE9x.c Demo_Init_1986BE91.c gl.c joystick.c lcd_1986BE9x.c lcd_1986BE91.c leds.c Main.c Menu.c Menu_gl.c Menu_leds.c Menu_text.c Menu_time.c Menu_tsensor.c Menu_uart.c Menu_VCOM.c Menu_lowpower.c systick.c
