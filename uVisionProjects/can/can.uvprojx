# Keil uVision project can.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./main/: main.c
software components: Device:Startup 1.5, Drivers:CAN 1.5, Drivers:PORT 1.5, Drivers:POWER 1.5, Drivers:RST_CLK 1.5
