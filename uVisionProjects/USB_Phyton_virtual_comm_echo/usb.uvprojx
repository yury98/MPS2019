# Keil uVision project usb.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usb +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./src/: main.c Startup.s opora_rst_clk.c 1986be9x_usb.c 1986BE9x_usb_device.c 1986BE9x_usb_CDC.c
software components: CMSIS:CORE 5.2.0
