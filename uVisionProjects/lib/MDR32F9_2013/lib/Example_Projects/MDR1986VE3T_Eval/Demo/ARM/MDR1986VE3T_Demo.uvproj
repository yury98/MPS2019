# Keil uVision project MDR1986VE3T_Demo.uvproj, settings and files
target Milandr MDR1986VE3T (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1") ESEL
  output: MDR1986VE3T
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress=47
  c include: ..\..\..\..\Libraries\CMSIS\CM1\CoreSupport;..\..\..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE3\inc;..\..\..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE3\startup\arm;..\..\Config;..\..\Inc;..\..\..\..\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;..\..\..\..\Libraries\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library
  scatter file: .\MDR1986VE3T.sct
  group MDR32F9Qx_FWLib
    ../../../../Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_iwdg.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c MDR32F9Qx_eth.c MDR32F9Qx_mil_std_1553.c
  group MDR32F9Qx_USBLib
    ../../../../Libraries/MDR32F9Qx_StdPeriph_Driver/src/USB_Library/: MDR32F9Qx_usb_CDC.c MDR32F9Qx_usb_device.c
  group MDR32F9Qx_FatFsLib
    ../../src_fatfs/: rtc.c ff.c mmc.c
  group Fonts
    ../../fonts/: Font_12x16.c Font_6x8.c Font_7x10_bold.c Font_7x10_thin.c
  group Target
    ../../../../Libraries/CMSIS/CM1/DeviceSupport/MDR1986VE3/startup/arm/: startup_MDR1986VE3.s system_MDR1986VE3.c
  group User
    ../../src/: text.c adc.c gl.c joystick.c leds.c Main.c Menu.c Menu_gl.c Menu_leds.c Menu_text.c Menu_time.c Menu_tsensor.c Menu_uart.c Menu_VCOM.c Menu_lowpower.c systick.c Demo_Init_MDR1986VE3.c lcd_MDR1986VE3.c MDR1986VE3_it.c
