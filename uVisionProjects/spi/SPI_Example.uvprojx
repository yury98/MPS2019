# Keil uVision project SPI_Example.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.5.2
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: SPI_example +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\CM1\CoreSupport;.\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup\arm;.\CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc;.\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR32F9Qx_StdPeriph_Driver\src;.\main
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group libaries
    ./CMSIS/CM1/DeviceSupport/MDR1986VE1T/startup/arm/: system_MDR1986VE1T.c startup_MDR1986VE1T.s
    ./MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c MDR32F9Qx_audio.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_eth.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_keypad.c MDR32F9Qx_led.c MDR32F9Qx_mil_std_1553.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
  group main
    ./main/: main.c
