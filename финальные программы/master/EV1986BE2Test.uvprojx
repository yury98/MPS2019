# Keil uVision project EV1986BE2Test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EV1986Test +hex
  c flags: Optim=2 oTime=1 v6Lang=1 v6LangP=1
  c include: .\Lib_Config;.\Libraries\1986BE9x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\1986BE9x\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\mlt;.\flash;C:\EV1986BE92_Rev3_Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MainSrc
    ./: main.c
    ./Libraries/CMSIS/CM3/DeviceSupport/1986BE9x/startup/arm/: system_1986BE9x.c startup_1986be9x.s
  group MProcLibSrc
    ./Libraries/1986BE9x_StdPeriph_Driver/src/: 1986be9x_uart.c 1986be9x_dma.c 1986be9x_eeprom.c 1986be9x_port.c 1986be9x_rst_clk.c
    ./: 1986be9x_it.c
    ./USB/: MDR32F9Qx_usb.c MDR32F9Qx_usb_CDC.c MDR32F9Qx_usb_device.c
  group MltSrc
    ./mlt/: mlt_lcd.c
  group Flash
    ./flash/: MilFlash.c
software components: CMSIS:CORE 5.2.0
