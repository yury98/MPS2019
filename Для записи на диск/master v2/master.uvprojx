# Keil uVision project master.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: master +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MainSrc
    ./: main.c 1986be9x_it.c USB_main.c UART_main.c CAN_main.c SSP_main.c
  group Lcd
    ./mlt/: mlt_lcd.c
software components: Device:Startup 1.5, Drivers:CAN 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5, Drivers:USB Library 1.5, Drivers:USB 1.5
